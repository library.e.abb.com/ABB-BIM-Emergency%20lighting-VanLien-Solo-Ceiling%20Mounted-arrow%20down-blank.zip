Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2019-11-29T16:29:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 29 16:29:38 2019 * Host: rvidrea-ro-de * Database: C:\Users\RVI\AppData\Local\Temp\{CF7758F3-BBE9-4D0D-9A2F-4C205475F1D6}\ifc * Database version: 5507 * Database creation date: Fri Nov 29 16:29:36 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Nov 29 16:29:37 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 29 16:29:37 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcLightFixture: SOLO-P/ZT+TS 250/58+TS 250/50, E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR:SOLO-P/ZT+TS 250/58+TS 250/50:1360925
In: V00
Type - PredefinedType: POINTSOURCE; Material: Color RGB 000-127-063, Color RGB 255-255-255, Color RGB 235-235-235
Type - Dimensions - Depth: 46 mm; Height: 190 mm; Rotation U-Axis Correction: 180 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 269 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Apparent Load: 0 W
Type - Electrical Engineering - Voltage: 230 V
Type - Identity Data - Article Type: SOLO-P/ZT+TS 250/58+TS 250/50; Base Family Version: 12.07; Category: EL_LIGHTFIXTURE; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Signalisation de chemin de fuite sortie de secours vers le bas; EMCS Version: 4.0; ETIM Article Class: EC001957; Family Version: 12.07; GLN: 8713812000008; Manufacturer: VanLien; Manufacturer URL: http://www.vanlien.be/ps/fulltilt/vanlien.cgi?co=NL&lang=fr&part=12525058; MEPcontent Class: EMERGENCY_LIGHTING_FIXTURE; Model: SOLO-P/ZT+TS 250/58+TS 250/50; OmniClass Number: 23.80.70.11.21; OmniClass Title: Emergency Lighting; Revit Version: 2017; Type Name: SOLO-P/ZT+TS 250/58+TS 250/50; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Fixtures; Back Arrow Down: no; Back Arrow Left: no; Back Arrow Right: no; Back Arrow Up: no; Back No Arrow: yes; Family Name: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR; Front Arrow Down: yes; Front Arrow Left: no; Front Arrow Right: no; Front Arrow Up: no
Type - Text - Article Description: Signalisation de chemin de fuite sortie de secours vers le bas; GTIN: 08713812762340+08713812764634+08713812764627; Manufacturer Art. No.: 6331031+12525058+12525050; Product Line: VanLien
Type - Pset_LightFixtureTypeCommon - Reference: SOLO-P/ZT+TS 250/58+TS 250/50
Pset_ManufacturerTypeInformation - Manufacturer: VanLien
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.418458 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00215395 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Design Option: Main Model; Function Code: E6350; Mark: 7
Other - Family: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR: SOLO-P/ZT+TS 250/58+TS 250/50; Family and Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR: SOLO-P/ZT+TS 250/58+TS 250/50; Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR: SOLO-P/ZT+TS 250/58+TS 250/50; Type Id: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_BE-FR: SOLO-P/ZT+TS 250/58+TS 250/50
Phasing - Phase Created: 4. Plan over 10 jaar
